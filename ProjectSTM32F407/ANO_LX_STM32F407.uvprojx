# Keil uVision project ANO_LX_STM32F407.uvprojx, settings and files
target Ano_LX (5060528::V5.06 update 5 (build 528)::..\..\..\ARM\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ANO_LX +hex
  AfterMake: fromelf.exe --bin -o ./ANO-LX.bin ./build/Ano_LX.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\build;..\FcSrc;..\DriversBsp;..\DriversMcu\STM32F407\Drivers;..\DriversMcu\STM32F407\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\DriversMcu\STM32F407\Libraries\CMSIS\Include;..\DriversMcu\STM32F407\Libraries\CMSIS\ST\STM32F4xx\Include;..\DriversMcu\STM32F407;..\UserDriver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FcSrc
    ../FcSrc/: SysConfig.h main.c Ano_Scheduler.c Ano_Scheduler.h User_Task.c User_Task.h Highconrtroll.c Highcontroll.h ANO_DT_LX.c ANO_DT_LX.h ANO_LX.c ANO_LX.h LX_FC_EXT_Sensor.c LX_FC_EXT_Sensor.h LX_FC_Fun.c LX_FC_Fun.h LX_FC_State.c LX_FC_State.h HorizontalControl.c HorizontalControl.h
  group DriversBsp
    ../DriversBsp/: Drv_BSP.c Drv_BSP.h Ano_Math.c Ano_Math.h Drv_AnoOf.c Drv_AnoOf.h Drv_UbloxGPS.c Drv_UbloxGPS.h
  group DriversMcu
    ../DriversMcu/STM32F407/: McuConfig.h
    ../DriversMcu/STM32F407/Drivers/: stm32f4xx_it.c Drv_Sys.c Drv_Sys.h Drv_adc.c Drv_adc.h Drv_led.c Drv_led.h stm32f4xx_conf.h Drv_PwmOut.c Drv_PwmOut.h Drv_RcIn.c Drv_RcIn.h Drv_Timer.c Drv_Timer.h Drv_Uart.c Drv_Uart.h
  group LibrariesMcu
    ../DriversMcu/STM32F407/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../DriversMcu/STM32F407/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../DriversMcu/STM32F407/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Doc
    ../Doc/: note.txt
  group UserDriver
    ../UserDriver/: Usart3_Pi.h Usart3_Pi.c README.md UserDataTransfer.c UserDataTransfer.h LinuxTelemetry.c LinuxTelemetry.h GroundStationRx.c GroundStationRx.h CarPoseXyUart.c CarPoseXyUart.h CAR_POSE_XY_UART_PROTOCOL_V2.0.md LINUX_UART2_PROTOCOL.md
